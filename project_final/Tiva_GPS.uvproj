# Keil uVision project Tiva_GPS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Tiva_GPS
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s
    ./Tiva/: main.c ports_init.c ports_init.h LCD_display.c measure_distance.c measure_distance.h LCD_display.h test.c test.h
    C:/Keil/ARM/Startup/TI/TM4C123/: system_TM4C123.c
